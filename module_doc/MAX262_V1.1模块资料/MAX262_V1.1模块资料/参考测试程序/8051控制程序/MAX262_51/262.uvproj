# Keil uVision project 262.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 262 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\262_51
  group Source Group 1
    ./: main.c max262.c delay.c
