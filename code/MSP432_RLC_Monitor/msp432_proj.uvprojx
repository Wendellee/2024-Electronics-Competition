# Keil uVision project msp432_proj.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IROM(0x00000000,0x00100000) IRAM(0x20000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msp432_proj
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401E__,ARM_MATH_CM4
  c misc: --diag_suppress=2803,1,1035
  c include: .\source;.\source\third_party\CMSIS\Include;.\source;.\source\app;.\source\app;..\CDLQ(23C题)
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group driver_lib
    ./source/ti/devices/msp432e4/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group app
    ./source/app/: main.c AD9959.c AD9959.h
    ./source/: delay.c delay.h button.c button.h system_init.c system_init.h uart.c uart.h ADS112C04.c ADS112C04.h ADS112C04_i2c.c ADS112C04_i2c.h uartstdio.c uartstdio.h AD9910.c AD9910.h tim.c tim.h adc.c adc.h
    ./: CD4051.c CD4051.h
  group system
    ./source/ti/devices/msp432e4/startup_system_files/: system_msp432e401y.c
    ./source/ti/devices/msp432e4/startup_system_files/keil/: startup_msp432e401y_uvision.s
software components: CMSIS:DSP 1.4.2
